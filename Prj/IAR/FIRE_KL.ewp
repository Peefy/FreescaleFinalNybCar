# IAR project FIRE_KL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\SD_CARD; ..\..\NYB_Car\Inc; ..\..\SlaveComputer; ..\..\HMI\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FIRE_KL.hex
  ILINK.IlinkOutputFile: FIRE_KL.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 3
  group App
    $EW_DIR$/NOW/App/: main.c MKL_it.c
  group Board
    $EW_DIR$/NOW/Board/Src/: FIRE_ASCII.c FIRE_LED.C FIRE_MKL_conf.c FIRE_NRF24L0.c FIRE_NRF24L0_MSG.c
  group Chip
    $EW_DIR$/NOW/Chip/Src/: misc.c MKL_adc.c MKL_dac.c MKL_dma.c MKL_flash.c MKL_gpio.c MKL_i2c.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    $EW_DIR$/NOW/Chip/Src/IAR/: startup_MKL.s system_MKL.c vectors.c
  group HMI
    $EW_DIR$/NOW/HMI/Src/: GUI.c GUIcustom.c key.c key_event.c
  group NYB_Car
    $EW_DIR$/NOW/NYB_Car/Src/: BoMaKaiGuan.c Config.c Display.c Game.c GetSensor.c KalmanFilter.c MotorControl.c NYB_Car_Init.c OLED.c Pose.c ServoControl.c sound.c TwoCars_Communication.c Ultrasonic.c
  group SlaveComputer
    $EW_DIR$/NOW/SlaveComputer/: LowerComputer_V2.c
